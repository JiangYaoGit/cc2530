<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Boot.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Boot</project>
        <configuration>CC2530 Boot Loader-uart1</configuration>
      </member>
      <member>
        <project>Boot</project>
        <configuration>CC2530 Boot Loader-uart0</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


