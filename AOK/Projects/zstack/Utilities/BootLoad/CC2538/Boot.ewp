# IAR project Boot.ewp, settings and files
configuration Basic (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; HAL_SB_BOOT_CODE
  ICCARM.CCIncludePath2: source; ..\source; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2538; ..\..\..\..\..\Components\driverlib\cc2538\inc; ..\..\..\..\..\Components\driverlib\cc2538\source; ..\..\..\..\..\Components\sdriverlib\cc2538\source; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\Application
  OBJCOPY.OOCOutputFile: cc2538-serial-bootloader.bin
  ILINK.IlinkOutputFile: Boot.out
  ILINK.IlinkIcfFile: boot.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../Source/: sb_board_cfg.c sb_board_cfg.h
    source/: sb_exec.c sb_exec.h sb_main.c sb_main.h sb_uart.c startup_ewarm.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_board.h hal_defs.h
  group HAL/Target/Drivers
    ../../../../../Components/driverlib/cc2538/source/: flash.h sys_ctrl.h
    ../../../../../Components/hal/target/CC2538/: hal_sys_ctrl.c
    ../../../../../Components/driverlib/cc2538/inc/: hw_ints.h hw_nvic.h hw_sys_ctrl.h hw_types.h
  group HAL/Target/Include
    ../../../../../Components/hal/target/_common/cc2538/: _hal_types.h
    ../../../../../Components/hal/target/CC2538/: hal_board_cfg.h hal_mcu.h hal_sys_ctrl.h hal_types.h iocc2538.h
  group Tools
    ./: boot.icf
