# IAR project HotelElockEndevice.ewp, settings and files
configuration RouterEB (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: OSC32K_CRYSTAL_INSTALLED=FALSE; HOLD_AUTO_START
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\Source; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration RouterEB-PA (8051, debug)
  as the first configuration, except:
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: HOLD_AUTO_START
configuration EndDeviceEB-PA (8051, debug)
  as the first configuration, except:
configuration RouterEB-AutoStart (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: OSC32K_CRYSTAL_INSTALLED=FALSE
configuration RouterEB-PA-AutoStart (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: OSC32K_CRYSTAL_INSTALLED=FALSE
configuration EndDeviceEB-AutoStart (8051, debug)
  as the first configuration, except:
configuration EndDeviceEB-PA-AutoStart (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: OSC32K_CRYSTAL_INSTALLED=FALSE
  group App/SampleDevice
    ../Source/: Readme.txt
  group App/SampleDevice/inc
    ../Source/: HotelElockEndeviceBoardCfg.h HotelElockEndeviceUserApp.h UserUart.h
  group App/SampleDevice/src
    ../Source/: HotelElockEndevice_key.c HotelElockEndeviceBoardCfg.c HotelElockEndeviceUart.c HotelElockEndeviceUserApp.c
  group WZCL
    ../../Source/: DeviceConfig.h hal_board_config.h Readme.txt
  group WZCL/Tools
    ../Source/Tools/: f8wDevice.cfg
